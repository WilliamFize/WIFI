# Keil uVision project nuc123_project.uvproj, settings and files
target nuc12c_project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC123LD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x10FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: nuc123_project +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c misc: --C99
  c include: ..\Library\Device\Nuvoton\NUC123\Include;..\Library\StdDriver\inc;..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC123.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
    ../Library/Device/Nuvoton/NUC123/Source/ARM/: startup_NUC123.s
  group User
    ../user/: main.c delay.c i2c_simulate.c wm8974.c dataflash.c system_adc.c system_timer.c strconv.c audio_control.c key.c descriptors.c hid_transfer.c aes.c wifi_core.c oled_dma.c display.c
  group Library
    ../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c usbd.c spi.c pdma.c
